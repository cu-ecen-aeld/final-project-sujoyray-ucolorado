IMAGE_INSTALL += " dropbear curl inotify-tools  e2fsprogs"



